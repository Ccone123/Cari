# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0xC0000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MALLOC +hex
  c flags: Optim=3
  c define: STM32F10X_XL,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\MALLOC;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\BEEP;..\HARDWARE\SRAM;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\HARDWARE\KEY;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\HARDWARE\RTC;..\HARDWARE\COMMAND;..\HARDWARE\FLASH;..\HARDWARE\SD;..\HARDWARE\SPI;..\HARDWARE\UART4;..\HARDWARE\USART3;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\COMMUNICATIONLCD;..\HARDWARE\PROCESSING;..\FreeModbus\modbus\rtu;..\FreeModbus\modbus\ascii;..\FreeModbus\modbus\functions;..\FreeModbus\modbus\include;..\FreeModbus\modbus\tcp;..\FreeModbus\port;..\HARDWARE\IIC;..\HARDWARE\Variance;..\HARDWARE\DATAWRITE;..\HARDWARE\OUTPUT;..\HARDWARE\CMD_QUEUE;..\HARDWARE\CALIBRATION;..\HARDWARE\EXPERMENT;..\HARDWARE\LU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/LU/: kalmanoperation.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/COMMAND/: command.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/USART3/: USART3.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/COMMUNICATIONLCD/: communication.c
    ../HARDWARE/UART4/: modbus_host.c
    ../HARDWARE/PROCESSING/: processing.c
    ../HARDWARE/IIC/: IICEEPROM.c
    ../HARDWARE/Variance/: variance.c
    ../HARDWARE/DATAWRITE/: datawr.c
    ../HARDWARE/OUTPUT/: output.c
    ../HARDWARE/CMD_QUEUE/: cmd_queue.c
    ../HARDWARE/CALIBRATION/: calibration.c
    ../HARDWARE/EXPERMENT/: experiment.c
    ../HARDWARE/txt/: record.txt
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_xl.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c
  group MALLOC
    ../MALLOC/: malloc.c
  group UCOSIII-BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group FreeModBus
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/ascii/: mbascii.c
    ../FreeModbus/modbus/tcp/: mbtcp.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/: mb.c
  group FreeModBus_Port
    ../FreeModbus/port/: portevent.c portserial.c porttimer.c
  group TXT
    ../HARDWARE/: record.txt
