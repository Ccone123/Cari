# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MALLOC +hex
  c flags: Optim=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\SRAM;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\HARDWARE\KEY;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\HARDWARE\COMMAND;..\HARDWARE\TIMER;..\HARDWARE\COM_PRESS;..\HARDWARE\FreeModbus\modbus\ascii;..\HARDWARE\FreeModbus\modbus\functions;..\HARDWARE\FreeModbus\modbus\include;..\HARDWARE\FreeModbus\modbus\rtu;..\HARDWARE\FreeModbus\modbus\tcp;..\HARDWARE\FreeModbus\port;..\HARDWARE\UART4;..\HARDWARE\STATIC;..\HARDWARE\LYNDIR_NO;..\HARDWARE\FUNCTIONPOINTER;..\HARDWARE\ADC;..\HARDWARE\IIC;..\HARDWARE\IICSSC;..\HARDWARE\KALMANOPERATION;..\HARDWARE\PID;..\HARDWARE\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/COMMAND/: command.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/COM_PRESS/: com_press.c
    ../HARDWARE/UART4/: usart4.c
    ../HARDWARE/LYNDIR_NO/: lyndir_no.c
    ../HARDWARE/FUNCTIONPOINTER/: functionpointer.c
    ../HARDWARE/ADC/: adc.c ntc.c
    ../HARDWARE/IIC/: iic.c MPL115A2.c sm5852.c
    ../HARDWARE/IICSSC/: iicssc.c
    ../HARDWARE/KALMANOPERATION/: kalmanoperation.c
    ../HARDWARE/PID/: PID_Ctrl.c
    ../HARDWARE/PWM/: pwm.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_adc.c
  group UCOSIII-BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group FreeModBus
    ../HARDWARE/FreeModbus/modbus/: mb.c
    ../HARDWARE/FreeModbus/modbus/ascii/: mbascii.c
    ../HARDWARE/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../HARDWARE/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../HARDWARE/FreeModbus/modbus/tcp/: mbtcp.c
  group FreeModBus_Port
    ../HARDWARE/FreeModbus/port/: porttimer.c portserial.c portevent.c
